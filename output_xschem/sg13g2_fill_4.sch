v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} -200 -300 0 0 {name=pVDD lab=VDD}
C {devices/ipin.sym} -200 -260 0 0 {name=pVSS lab=VSS}
